# Autodesk Inventor part: D298-PF_15MM
## iProperties
Created: 2012-02
Part Number: D298-PF_15MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
